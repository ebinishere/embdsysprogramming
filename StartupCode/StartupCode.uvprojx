# Keil uVision project StartupCode.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ATSAM3X8E Atmel
  pack: Keil.SAM3_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x20080000,0x00008000) IROM(0x00080000,0x00040000) IROM2(0x000C0000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: StartupCode
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x80000 size 0x40000
  memory RVCT5: ROM 0xc0000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20080000 size 0x8000
